## sdkconfig.defaults
```kconfig
CONFIG_ADC_CONTINUOUS_ENABLE=y
CONFIG_DSP_MAX_FFT_SIZE=1024
CONFIG_ESPTOOLPY_FLASHFREQ_40M=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
```
